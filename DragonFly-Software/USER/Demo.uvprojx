# Keil uVision project Demo.uvprojx, settings and files
target DragonFly (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F411xE,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\DRIVER\inc;..\FWLIB;..\FWLIB\inc;..\IMU;..\CONTROL;..\COMMUNICATE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group DERIVR
    ../DRIVER/src/: delay.c exit.c iic_moni.c led.c nrf2401.c nvicconfig.c spi.c timer.c usart.c fbm320.c mpu9250.c flash.c power.c motor.c openmv.c ICM20948.c spl06.c
  group IMU
    ../IMU/: filter.c imu.c structconfig.h
  group CONTROL
    ../CONTROL/: control.c paramsave.c pid.c altitude.c
  group COMMNUICATE
    ../COMMUNICATE/: ANO_DT.c remotedata.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../FWLIB/: startup_stm32f411xe.s
  group Read me
    ../: Read me.txt
